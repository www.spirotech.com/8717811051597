Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: HC_Expansion Vessel_F_MEPcontent_Spirotech_SpiroExpand_EVN140_INT-EN.ifc
Time: 2025-08-05T18:33:00+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcBuildingElementProxy: HC_Expansion Vessel_F_MEPcontent_Spirotech_SpiroExpand_EVN_INT-EN:EVN140, HC_Expansion Vessel_F_MEPcontent_Spirotech_SpiroExpand_EVN_INT-EN:EVN140:2111261
In: F00
Type - Material: Color RGB 040-040-040, Color RGB 251-203-029
Type - Other - Category: Mechanical Equipment; Arc: 33 mm; Arc Logo: 900 mm; Belt: yes; Distance Support: 10.7019 mm; Family Name: HC_Expansion Vessel_F_MEPcontent_Spirotech_SpiroExpand_EVN_INT-EN; Length Support: 260 mm; M: 100 mm; Q: 80 mm; S: 133 mm; Suport Visibility: yes; Support 100: no; Support 140: yes; Support 25: no; Support 35: no; Support 4: no; Support 50: no; Support 80: no; t: 193 mm; Visibility 1: no; Visibility 2: yes
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Diameter: 19 mm; Height: 572 mm; Use Nominal Diameter: yes; Width: 600 mm
Type - Identity Data - Article Description: EVN Safety expansion vessel (3 bar) 140 litres; Article Type: EVN140; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: EVN Safety expansion vessel (3 bar) 140 litres; EMCS Version: 4.0; ETIM Article Class: EC010958; Family Version: 22.10; GLN: 8717811000007; GTIN: 8717811056660; Manufacturer: Spirotech; Manufacturer Art. No.: EVN140; Manufacturer URL: https://www.spirotech.com/8717811056660; MEPcontent Class: EXPANSIONVASSEL; Model: EVN140; OmniClass Number: 23.75.70.11.14; OmniClass Title: Expansion Vessels; Product Line: Spirotech; Revit Version: 2023; Type Name: EVN140; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Dark Grey: Color RGB 040-040-040; Yellow: Color RGB 251-203-029
Type - Mechanical - Max.Safety Temperature: 100 C; Standard Gas Presure: 1 bar; Volume: 0.14 m3; Weight: 20 kg
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_BuildingElementProxyCommon - Reference: EVN140; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: EVN140
Other - Family: HC_Expansion Vessel_F_MEPcontent_Spirotech_SpiroExpand_EVN_INT-EN; Family and Type: HC_Expansion Vessel_F_MEPcontent_Spirotech_SpiroExpand_EVN_INT-EN: EVN140; Type: EVN140; Type Id: 2111228
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 0.769608 m2; Volume: 0.144769 m3
Identity Data - Mark: 4
Mechanical - Flow: 0 m3/s; System Classification: Undefined
Phasing - Phase Created: 3. New Construction

# IfcDistributionPort, InPort_2111261_1
Description: Flow; FlowDirection: SINK; PredefinedType: PIPE
